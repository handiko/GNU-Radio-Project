<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>APRS_AFSK_Complete_WAV</value></param>
<param><key>author</key><value>Handiko</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>APRS - AFSK Decoder (Test)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud</value></param>
<param><key>value</key><value>300</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>24e3</value></param>
</block>
<block>
<key>AFSK_Demod</key>
<param><key>id</key><value>AFSK_Demod_0</value></param>
<param><key>baud</key><value>baud</value></param>
<param><key>fsk_hi_tone</key><value>600</value></param>
<param><key>fsk_lo_tone</key><value>300</value></param>
<param><key>in_sps</key><value>int(samp_rate / baud)</value></param>
<param><key>out_sps</key><value>4</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate </value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>comment</key><value>File : gr-APRS/WAV/aprs.wav
sample rate : 24 kHz
bit depth : 16 bits</value></param>
<param><key>file</key><value>/home/handiko/gr-APRS/WAV/aprs_random.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>firdes.band_pass(1,samp_rate,200,800,100,firdes.WIN_BLACKMAN)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate </value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024*4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate / (80 / 2)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>int(1200 / baud)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<connection><source_block_id>AFSK_Demod_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>AFSK_Demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
